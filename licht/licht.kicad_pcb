# Repository microresearch/ERD-breath

## KiCad design licht/licht.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C10: 100N; C_0805_HandSoldering
C6, C8: 10UF; CP_Tantalum_Case-A_EIA-3216-18_Hand
C9: 10PF; C_0805_HandSoldering
C11: 10N; C_0805_HandSoldering
C12: 100NF; C_0805_HandSoldering
D1, D2: BAT; D_SOD-123
D3: D_Photo; PhotoDiode_BPW82
D4, D5: 1N4148; D_SOD-123
J1: Conn_02x05_Odd_Even; Pin_Header_Straight_2x05_Pitch2.54mm
M1, M2: AUDIO-JACKERTHENVAR; ERTHENVAR-JACK
R1, R3, R4, R5, R7, R8: 10K; R_0805_HandSoldering
R2, R11, R12, R13: 1K; R_0805_HandSoldering
R6: 470R; R_0805_HandSoldering
R9: 4.7K; R_0805_HandSoldering
R10: 200K; R_0805_HandSoldering
R14, R15, R16, R17: 10R; R_0805_HandSoldering
R18: 100K; R_0805_HandSoldering
RV1: 100K; Potentiometer_Alps_RK09K_Horizontal
U1: TL084; SOIC-14_N
U2: TL082; SOIC-8-N

Connections:
+12V: C5.1, C6.1, D1.1 (K), R1.2, R14.2, R16.2
-12V: C7.1, C8.2, D2.2 (A), R8.1, R15.1, R17.1
GND: C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C10.2, D3.2 (A), D4.1 (K), J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, M1.1@1 (RING), M1.1@2 (RING), M2.1@1 (RING), M2.1@2 (RING), R2.1, R6.1, R7.2, R10.1, R12.2, R18.1, U1.3 (+)
unnamed: C1.1, R3.2, U1.12 (+)
unnamed: C1.2, RV1.1, RV1.2, U1.8
unnamed: C2.2, R14.1, U1.4 (V+)
unnamed: C3.1, R16.1, U2.8 (V+)
unnamed: C4.1, R15.2, U1.11 (V-)
unnamed: C9.1, D3.1 (K), R5.2, U1.2 (-)
unnamed: C10.1, R17.2, U2.4 (V-)
unnamed: C11.1, U2.1
unnamed: C11.2, D4.2 (A), R10.2, U2.6 (-)
unnamed: C9.2, C12.1, R5.1, U1.1
unnamed: C12.2, R18.2, U1.5 (+)
unnamed: D1.2 (A), J1.1, J1.2
unnamed: D2.1 (K), J1.9, J1.10
unnamed: D5.1 (K), R13.1
unnamed: D5.2 (A), U2.7
unnamed: M1.3 (TIP), R11.2
unnamed: M2.3 (TIP), R12.1, R13.2
unnamed: R1.1, R2.2, R4.2
unnamed: R3.1, U2.2 (-)
unnamed: R4.1, U2.3 (+)
unnamed: R6.2, R9.1, U1.9 (-)
unnamed: R7.1, R8.2, U2.5 (+)
unnamed: R9.2, RV1.3
unnamed: R11.1, U1.13 (-), U1.14
unnamed: U1.6 (-), U1.7, U1.10 (+)

Notes on the sheet:
no input, two outs (signal and gate), one pot
tested and working - signal is positive!
non-inverting buffer
optional cap

Board: 2 copper layers, 36.6 x 77.4 mm, 41 parts (36 on the bottom side), 28 nets.

## KiCad design breath.kicad_pcb

Board: 2 copper layers, 40.7 x 106.8 mm, 27 parts (19 on the bottom side), 21 nets.

Parts:
C1, C3: 100N; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2, C4: CP_Small; CP_Radial_D5.0mm_P2.00mm
D1, D2, D3: BAT; D_DO-15_P10.16mm_Horizontal
D4: 1N5820; D_DO-201_P12.70mm_Horizontal
J1: Conn_02x05_Odd_Even; Pin_Header_Angled_2x05_Pitch2.54mm
J2, J4: Barrel_Jack_Switch; BARREL_JACK
J3: Conn_01x02_Male; Pin_Header_Straight_1x02_Pitch2.54mm
M1: AUDIO-JACKERTHENVAR; ERTHENVAR-JACK
Q1, Q2: TIP3055; TO-218_SOT93_Horizontal
R1: 18K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R5: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7: 200R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9: 0.1R; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
RV1, RV2: 10K; Potentiometer_Alps_RK09K_Horizontal
U1: TL084; DIP-14_W7.62mm_Socket_LongPads

Connections:
+12V: C1.1, C2.1, D1.1, RV2.1, U1.4
+15V: J2.2, J4.1
-12V: C3.1, C4.2, D2.2, U1.11
GND: C1.2, C2.2, C3.2, C4.1, D3.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J4.2, M1.1@1, M1.1@2, M1.2, R8.1, R9.1, RV1.3, RV2.3, U1.3, U1.5
unnamed: D1.2, J1.1, J1.2
unnamed: D2.1, J1.9, J1.10
unnamed: D3.1, R5.1, U1.7, U1.10
unnamed: D4.1, J3.2, Q1.2, Q2.2
unnamed: D4.2, J2.1
unnamed: J2.3, J3.1
unnamed: M1.3, RV1.1
unnamed: Q1.1, R7.1
unnamed: Q1.3, R8.2
unnamed: Q2.1, R6.1
unnamed: Q2.3, R9.2
unnamed: R1.1, R2.1, R3.2, U1.2
unnamed: R1.2, RV1.2
unnamed: R2.2, RV2.2
unnamed: R3.1, R4.2, U1.1
unnamed: R4.1, R5.2, U1.6
unnamed: R6.2, R7.2, U1.8, U1.9

## Commit log

2019-06-11 furst
2019-06-11 schem
2019-08-26 changed R1 to 18k
2019-08-26 light
2019-08-26 licht
2019-10-15 fixed wrong footprint, removed c10, changed comp value
2019-10-15 fixed possible comp error to test
2019-11-05 new erd/licht schematic and pcb
2019-11-05 licht layout pdf
2019-11-06 new version
2019-11-08 new pcb to test
2019-11-18 labe;ls
